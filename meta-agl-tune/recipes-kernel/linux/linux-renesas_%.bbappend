FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

# we just override defconfig, which is 'SRC_URI'ed in other append
