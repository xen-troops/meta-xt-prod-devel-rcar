IMAGE_INSTALL:append = " \
    lisot \
"
